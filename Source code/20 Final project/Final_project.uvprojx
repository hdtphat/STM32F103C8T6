# Keil uVision project Final_project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Final_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main source
    ./: main.c
  group Lib source
    ./: Clock.c GPIO.c Timers.c EXTI.c ADC.c NVIC.c
  group Lib header
    ./: Clock.h GPIO.h Timers.h EXTI.h ADC.h NVIC.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
